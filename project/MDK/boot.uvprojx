# Keil uVision project boot.uvprojx, settings and files
target hc32l13x_boot (6070000::V6.7::.\ARMCLANG)
  device: HC32F005C6UA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: iap +hex
  AfterMake: fromelf  --bin  -o ./output/release/iap.bin ./output/release/iap.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HC32F005
  c include: ..\source;..\..\driver;..\..\app;..\..\driver\inc;..\..\driver\hc32f005;..\..\driver\src;..\..\driver\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT9: RAM 0x20000000 size 0x1000
  group common
    ./: startup_hc32f005.s
  group source
    ../source/: main.c
  group driver
    ../../driver/: basic.c
  group iap
    ../../app/: modem.c iap.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
